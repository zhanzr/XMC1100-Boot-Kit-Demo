# Keil uVision project gpio_toggle_xmc11.uvprojx, settings and files
target gpio_toggle_xmc11 (6240000::V6.24::ARMCLANG)
  device: XMC1100-T038x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.12.0
  cpu: IROM(0x10001000,0x10000) IRAM(0x20000000,0x3FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gpio_toggle_xmc11
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-extra-semi-stmt
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  scatter file: .\RTE\Device\XMC1100-T038x0064\XMC1100x0064_ac6.sct
  group Source
    ../: main.c lcd_pwm_vo.c lcd2004.c led.c retarget_io_drv.c
  group Doc
    ../: Readme.txt
software components: CMSIS-Compiler:CORE 1.2.1, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.2.0, Device:Startup 3.0.0, Device:XMClib:CCU4 2.2.0, Device:XMClib:FLASH 2.2.0, Device:XMClib:GPIO 2.2.0, Device:XMClib:RTC 2.2.0, Device:XMClib:SCU 2.2.0, Device:XMClib:UART 2.2.0
