# Keil uVision project cstyle_template.uvprojx, settings and files
target lcm2004_4bit (6240000::V6.24::ARMCLANG)
  device: XMC1100-T038x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.12.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: elfout
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: XMC1100_T038x0064
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Source Files
    ./: main.c led.c xmc1100_it.c lcd2004.c lcd_pwm_vo.c retarget_io_drv.c
  group Documentation
    ./: README.md
software components: CMSIS:CORE 6.2.0, Device:Startup 3.0.0, Device:XMClib:CCU4 2.2.0, Device:XMClib:FLASH 2.2.0, Device:XMClib:GPIO 2.2.0, Device:XMClib:RTC 2.2.0, Device:XMClib:SCU 2.2.0, Device:XMClib:UART 2.2.0
